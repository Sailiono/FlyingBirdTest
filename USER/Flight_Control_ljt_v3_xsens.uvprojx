# Keil uVision project Flight_Control_ljt_v3_xsens.uvprojx, settings and files
target Flight_Control_ljt_v3_xsens (5060960::V5.06 update 7 (build 960)::.\Arm Compiler 5.06)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Flight_Control_ljt_v2 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\FWLIB\inc;..\MODULES;..\DRIVERS\eMPL;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\include;..\CONFIG;..\COMMUNICATE;..\COMMONLIB\interface;..\FATFS;..\DRIVERS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group DRIVERS
    ../DRIVERS/: timer.c watchdog.c sdio_sdcard.c led.c bsp_spi_ad7606.c spi.c 2stm.c 24cxx.c sbus.c myiic.c adxrs290.c imu.c imu2.c wind.c rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_iwdg.c stm32f4xx_adc.c stm32f4xx_exti.c
  group README
    ../: readme.txt
  group MODULES
    ../MODULES/: flight_log.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FATFS
    ../FATFS/: ff.c diskio.c cc936.c exfuns.c malloc.c
